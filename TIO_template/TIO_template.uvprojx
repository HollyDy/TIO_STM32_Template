# Keil uVision project TIO_template.uvprojx, settings and files
target TIO_TEMPLATE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIO_TEMPLATE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\LIB\inc;.\LIB\src;.\MAIN;.\Listings;.\HARDWARE;.\CONF
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x.h
  group MAIN
    ./MAIN/: main.c stm32f10x_it.c
  group LIB
    ./LIB/src/: stm32f10x_rcc.c stm32f10x_gpio.c
